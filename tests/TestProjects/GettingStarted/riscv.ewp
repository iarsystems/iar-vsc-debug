# IAR project riscv.ewp, settings and files
configuration Debug (RISCV, debug)
  General.GDeviceSelect: RV32 RV32
  General.GHeapSize: 0x1000
  ICCRISCV.IccLang: 2
  ICCRISCV.CCOptLevel: 1
  ICCRISCV.CCOptStrategy: 0
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkOutputFile: riscv.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: Fibonacci.c Utilities.c Stl.cpp
