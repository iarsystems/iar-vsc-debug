# IAR project BasicDebugging.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F429II ST STM32F429II
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: BasicDebugging.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
configuration Debug2 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: AM6548_A53_SS1 TexasInstruments AM6548_A53_SS1
  General.CoreVariant: 63
  General.FPU2: 0
configuration STM (ARM, debug)
  as the first configuration, except:
  group (top)
    ./: Fibonacci.c Utilities.c
