# IAR project TestProj.ewp, settings and files
configuration Debug (ARM, debug)
  group (top)
    ./: main.c
