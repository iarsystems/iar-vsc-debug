# IAR project BasicProject.ewp, settings and files
configuration Test ($TOOLCHAIN_NAME$, debug)
  group (top)
    ./: main.c
