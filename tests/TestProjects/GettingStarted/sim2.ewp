# IAR project sim2.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Zynq 7020 Xilinx Zynq 7020
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  General.CoreVariant: 56
  General.FPU2: 3
  ICCARM.CCDefines: ZYNQ7020=1
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: sim2.out
  ILINK.IlinkIcfFile: zynq7020.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: cstartup.s Fibonacci.c Utilities.c
